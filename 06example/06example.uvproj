# Keil uVision project 06example.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 06example +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c smg.h public.h key.h timer.h interrupt.h interrupt.c key.c public.c smg.c timer.c lcd1602.h lcd1602.c ds18b20.h ds18b20.c buzzer.h buzzer.c
